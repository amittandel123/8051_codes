# Keil uVision project LCD_SERIAL.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RD2xx Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: LCD_SERIAL +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    F:/training/HW/LCD_SERIAL/: STARTUP.A51
    ./: LCDD.c Transmit.c
